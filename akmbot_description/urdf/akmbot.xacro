Commit message: 更新readme

File: akmbot_description/urdf/akmbot.xacro (robot description, xacro)
@@ -327,5 +327,5 @@
         <parent link="base_link" />
         <child link="imu" />
-        <origin xyz="0 0 0.02" />
+        <origin xyz="0 0 0.12" />
         <axis xyz="0 0 1" />
     </joint>
